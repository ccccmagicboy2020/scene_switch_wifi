# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: 003_ISP_NEW +hex
  c flags: Optimize=9
  c include: ..\user;..\include
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c Public.c Uart.c Modb.c Flash.c
